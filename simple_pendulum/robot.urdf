Commit message: Update demo.

File: simple_pendulum/robot.urdf (robot description, URDF)
Before this commit: robot pendulum, 3 links, 2 joints
Joints:
- joint PendulumJoint: limit effort=20.0 velocity=100.0 -> effort=20.0 velocity=30.0
